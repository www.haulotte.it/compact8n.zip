Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2023-03-13T10:22:45
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190510_1515(x64) - Exporter 18.3.3.18 - Alternate UI 18.3.3.18
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Mar 13 10:22:45 2023 * Host: DESKTOP-BV15NV9 * Database: C:\Users\Walter\AppData\Local\Temp\{1A2A75B6-ECF7-4C6D-85BD-6A53BE0C0C6F}\ifc * Database version: 5507 * Database creation date: Mon Mar 13 10:22:39 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Mar 13 10:22:39 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Mar 13 10:22:39 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Center; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcBuildingElementProxy: COMPACT 8N, Construction_Aerial-Equipment_Haulotte_Compact-8N_INT:COMPACT 8N:378036
In: Level 1
Type - Classification: E1030100 Vehicular Service Equipment (Uniformat); Material: Haulotte - Metal - Black RAL 9017, Haulotte - Metal - White, Working_Area, Haulotte - Metal - White RAL 9010, Haulotte - Metal - Yellow RAL 1006, Haulotte - Metal - Red RAL 3020
Type - Data - Batteries: 4x6V- 185 Ah; Driveable at Full Height up to: 6000 mm/ 236.2 in; Drive Speed: 0.7-4.2 km/h / 0.4-2.6 mph; Gradeability: 25%; Ground Clearance: 125 mm / 4.9 in; Ground Clearance - Pothole Guards Deployed: 20 mm / 0.8 in; Height - Stowed: 1820 mm/ 71.7 in; Hydraulic System Capacity: 10 l / 2.6 gal; Length: 2500 mm/ 98.4 in; Length Extension: 920 mm/ 36.22 in; Lift Capacity – Inside: 350 kg / 772 lb; Lift Capacity - Outside: 350 kg / 772 lb; Machine Weight: 2120 kg/ 4674 lb; Max Ground Pressure of Wheel on Paved Ground: 17.3 kg/cm2; Overall width: 818 mm/ 32.2 in; Platform Height: 6000 mm/ 236.2 in; Platform Length - Extended: 3320 mm/ 130.7 in; Platform Length - Outside: 2400 mm/ 94.5 in; Platform Width – Outside: 795 mm/ 31.3 in; Tilt lateral / longitudinal: ±1,5° / ±3,5°; Tires: 380x129mm/15x5.1 in; Turning Radius - Inside: 2050 mm/ 80.7 in; Turning Radius - Outside: 460 mm / 18.1 in; Wheelbase: 1860 mm/ 73.22 in; Working Height: 8000 mm/315.0 in
Type - Identity Data - Assembly Code: E1030100; Assembly Description: Vehicular Service Equipment; Keynote: 11000; Manufacturer: Haulotte; Model: Compact 8N; OmniClass Number: 23.15.99.00; OmniClass Title: Other Utility and Transportation Construction Products; Product data url: https://www.bimobject.com/haulotte/product/compact8n; Type Name: COMPACT 8N; URL: http://www.haulotte-usa.com/
Type - Other - Category: Specialty Equipment; Family Name: Construction_Aerial-Equipment_Haulotte_Compact-8N_INT; z_Main Beam Length: 2150 mm; z_Minor Beam Length: 2150.02 mm
Pset_BuildingElementProxyCommon - Reference: COMPACT 8N
Pset_ManufacturerTypeInformation - Manufacturer: Haulotte
Constraints - Host: Level : Level 1; Level: Level: Level 1; Moves With Nearby Elements: no; Offset: 0 mm
Construction - Extension Desk Length: 10000 mm; Platform Height: 10000 mm; Reach Diagram: no; Turning Radius: yes; Working Area: yes
Dimensions - Area: 47.5555 m2; Volume: 18.4524 m3
Graphics - Branding: yes
Other - Family: Construction_Aerial-Equipment_Haulotte_Compact-8N_INT: COMPACT 8N; Family and Type: Construction_Aerial-Equipment_Haulotte_Compact-8N_INT: COMPACT 8N; H CTRL: 5276.5 mm; L: 1423.14 mm; Type: Construction_Aerial-Equipment_Haulotte_Compact-8N_INT: COMPACT 8N; Type Id: Construction_Aerial-Equipment_Haulotte_Compact-8N_INT: COMPACT 8N; z_Center Blue Dist: 569.63 mm; z_Hinge Distance: 155.226 mm; z_H Main X CTRL: 1726.57 mm; z_H Minor X: 1823.37 mm; z_Main Cross Dist: 958.922 mm; Z_Red Blue Dist: 1281.2 mm; z_α: 36.5773 deg; z_β: 106.845 deg
Phasing - Phase Created: New Construction
